<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\xmega_applications_xmega_a1_xplained_demo_atxmega128a1_xmega_a1_xplained.ewp</path>
  </project>
  <batchBuild/>
</workspace>
