# IAR project xmega_applications_xmega_a1_xplained_demo_atxmega128a1_xmega_a1_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..\..\..\..\drivers\cpu; ..\..\..\..\..\common\services\gpio; ..\..; ..; ..\..\..\..\utils; ..\..\..\..\drivers\nvm; ..\..\..\..\..\common\services\clock; ..\..\..\..\drivers\sleep; ..\..\..\..\boards\xmega_a1_xplained; ..\..\..\..\boards; ..\..\..\..\drivers\pmic; ..\..\..\..\..\common\boards; ..\..\..\..\..\common\utils; ..\..\..\..\drivers\tc; ..\..\..\..\drivers\ioport; ..\..\..\..\drivers\dac; ..\..\..\..\utils\preprocessor; ..\..\..\..\..\common\services\sleepmgr; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XMEGA_A1_XPLAINED
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED
  XLINK.XclFile: lnk0t.xcl
  group xmega/boards/xmega_a1_xplained
    ../../../../boards/xmega_a1_xplained/: init.c
  group xmega/applications/xmega_a1_xplained_demo
    ../../: sound.c main.c snd_samples.c
  group xmega/drivers/ioport
    ../../../../drivers/ioport/: ioport.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/dac
    ../../../../drivers/dac/: dac.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
